# IAR project Lpc213x_demo.ewp, settings and files
configuration Debug RAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC2138 Philips LPC2138
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCIncludePath2: App\; Board\; modules\; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Lpc213x_demo.out
  ILINK.IlinkIcfFile: config\RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FLASH
  OBJCOPY.OOCOutputFile: Lpc213x_demo.srec
  ILINK.IlinkIcfFile: CONFIG\Flash.icf
  group (top)
    app/: demo.c user_func.c
  group Modul Source
    modules/: drv_hd44780.c drv_hd44780_l.c LPC_Rtc.c LPC_SysControl.c LPC_Timer.c LPC_Uart.c LPC_Vic.c menu.c
